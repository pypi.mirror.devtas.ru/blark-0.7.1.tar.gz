PROGRAM MAIN
VAR
	bProjectB : BOOL;
	fbLogger : FB_LogHandler;
END_VAR

fbLogger();

END_PROGRAM
