FUNCTION_BLOCK FB_ProjectA
VAR_INPUT
	fValue : LREAL;
END_VAR
VAR_OUTPUT
END_VAR
VAR
END_VAR

fValue := 1.0;

END_FUNCTION_BLOCK
